FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
	    file://bridge-utils.cfg \
           "
