SYSTEMD_SERVICE:${PN} += "avahi-daemon.service"

